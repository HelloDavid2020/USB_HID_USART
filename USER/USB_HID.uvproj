# Keil uVision project USB_HID.uvproj, settings and files
target USB_HID (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: jiao_stm32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\USER;..\CMSIS;..\LIB\inc;..\LIB\src;..\USB_library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c usart1.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c user_gpio.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c
  group STARTUPCODE
    ../CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group USB_LIB
    ../USB_library/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
